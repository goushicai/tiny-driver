# Keil uVision project stm32_st7735s.uvprojx, settings and files
target st7735s (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_st7735s +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\sys\CMSIS\Core\Include;..\sys\CMSIS\Device\ST\STM32F1xx\Include;..\sys\STM32F1xx_HAL_Driver\Inc;..\msp;..\bsp;..\drv;..\lib;..\api;..\res;..\ui;..\app;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys/CMSIS
    ../sys/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    ../sys/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group sys/STM32_HAL
    ../sys/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group msp
    ../msp/: gpio.c rcc.c spi.c uart.c msp.h stm32f1xx_it.c
  group bsp
    ../bsp/: led.c bsp.h
  group drv
    ../drv/: st7735s.c
  group api
    ../api/: display.c api.h
  group res
    ../res/: color.h font.h pic.h
  group app
    ../app/: main.c
  group config
    ../config/: display_config.h gpio_config.h st7735s_config.h
