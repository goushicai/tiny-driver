# Keil uVision project acm32f403_7735s.uvprojx, settings and files
target acm32f403 (6130001::V6.13.1::.\ARMCLANG)
  device: ACM32F403CET7 Aisinochip
  pack: Aisinochip.ACM32F4.1.0.2
  cpu: IRAM(0x20000000,0x30000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: acm32f403_7735s +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\sys\CMSIS;..\sys\Device;..\sys\HAL_Driver\Inc;..\msp;..\bsp;..\drv;..\lib;..\api;..\res;..\config;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group sys/CMSIS
    ../sys/CMSIS/: core_cm33.h
  group sys/Device
    ../sys/Device/: System_ACM32F4.c Startup_ACM32F4.s
  group sys/HAL
    ../sys/HAL_Driver/Src/: HAL_EFlash.c HAL_EXTI.c HAL_GPIO.c HAL_SPI.c HAL_UART.c HAL_UART_EX.c HAL_EFlash_EX.lib HAL_DMA.c
  group msp
    ../msp/: gpio.c spi.c uart.c
  group bsp
    ../bsp/: led.c
  group drv
    ../drv/: st7735s.c
  group api
    ../api/: display.c
  group config
    ../config/: display_config.h gpio_config.h st7735s_config.h
  group res
    ../res/: color.h font.h pic.h
  group app
    ../app/: main.c
