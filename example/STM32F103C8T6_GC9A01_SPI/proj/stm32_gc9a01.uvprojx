# Keil uVision project stm32_gc9a01.uvprojx, settings and files
target stm32_gc9a01 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32_gc9a01 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\sys\CMSIS\Core\Include;..\sys\CMSIS\Device\ST\STM32F1xx\Include;..\sys\STM32F1xx_HAL_Driver\Inc;..\msp;..\bsp;..\drv;..\lib;..\res;..\api;..\ui;..\app;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys/CMSIS
    ../sys/CMSIS/: startup_stm32f103xb.s system_stm32f1xx.c
  group sys/STM32_HAL
    ../sys/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group config
    ../config/: display_config.h gc9a01_config.h gpio_config.h
  group app
    ../app/: main.c
  group msp
    ../msp/: rcc.c gpio.c spi.c stm32f1xx_it.c uart.c
  group bsp
    ../bsp/: led.c
  group drv
    ../drv/: gc9a01.c
  group res
    ../res/: pic.h font.h color.h
  group api
    ../api/: display.c
